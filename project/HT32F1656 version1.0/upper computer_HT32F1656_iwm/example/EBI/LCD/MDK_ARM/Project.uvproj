# Keil uVision project Project.uvproj, settings and files
target HT32 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: HT32F1656 Holtek
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x00000000-0x0003FBFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HT32 +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F1656_DVB
  c include: ..\;..\..\..\..\library\HT32F1655_56_Driver\inc;..\..\..\..\library\CMSIS\Include;..\..\..\..\library\Device\Holtek\HT32F1655_56\Include;..\..\..\..\library\HT32_USBD_Library\inc;..\..\..\..\utilities;..\delay;..\..\..\..\utilities\common;..\..\..\..\HARDWARE\usart;..\..\..\..\HARDWARE\TIM;..\..\..\..\HARDWARE\EXTI;..\..\..\..\HARDWARE\IIC;..\..\..\..\HARDWARE\MAX30102;..\..\..\..\HARDWARE\wenshidu;..\..\..\..\HARDWARE\ESP8266;..\..\..\..\HARDWARE\TEXT;..\..\..\..\HARDWARE\MLX90614;..\..\..\..\HARDWARE\WDT;..\..\..\..\HARDWARE\LIGHT_VOICE;..\..\..\..\HARDWARE\matrix
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3fc00
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group User
    ../: main.c ht32f165x_it.c
  group Config
    ../: ht32f1655_56_conf.h ht32f165x_usbdconf.h
    ../MDK_ARM/: ht32_op.s
    ./: HT32F165x_DebugSupport.ini
  group CMSIS
    ../: system_ht32f165x.c
  group MDK-ARM
    ./: startup_ht32f165x.s
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Library
    ../../../../library/HT32F1655_56_Driver/src/: ht32_cm3_misc.c ht32f1655_56_adc.c ht32f1655_56_bftm.c ht32f1655_56_ckcu.c ht32f1655_56_cmp_op.c ht32f1655_56_crc.c ht32f1655_56_ebi.c ht32f1655_56_exti.c ht32f1655_56_flash.c ht32f1655_56_gpio.c ht32f1655_56_gptm.c ht32f1655_56_i2c.c ht32f1655_56_i2s.c ht32f1655_56_mctm.c ht32f1655_56_pdma.c ht32f1655_56_pwrcu.c ht32f1655_56_rstcu.c ht32f1655_56_rtc.c ht32f1655_56_sci.c ht32f1655_56_spi.c ht32f1655_56_usart.c ht32f1655_56_usbd.c ht32f1655_56_wdt.c
  group Retarget
    ../../../../library/HT32F1655_56_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: i2c_eeprom.c spi_flash.c ebi_lcd.c
  group Doc
    ../: readme.txt
  group HARDWAR
    ../delay/: delay.c
    ../../../../HARDWARE/usart/: usart.c
    ../../../../HARDWARE/EXTI/: exti.c
    ../../../../HARDWARE/MAX30102/: algorithm.c max30102.c myiic.c
    ../../../../HARDWARE/wenshidu/: sht3x.c
    ../../../../HARDWARE/ESP8266/: ESP8266.c
    ../../../../HARDWARE/MLX90614/: MLX90614.c
    ../../../../HARDWARE/WDT/: wdt.c
    ../../../../HARDWARE/LIGHT_VOICE/: light_voice.c
    ../../../../HARDWARE/matrix/: matrix.c
